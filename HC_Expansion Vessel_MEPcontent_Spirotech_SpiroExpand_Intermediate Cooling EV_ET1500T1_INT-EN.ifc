Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: , VersionGUID: f3a51646-a1de-4539-a2f9-f600db158adc, NumberOfSaves: 173]
File name: HC_Expansion Vessel_MEPcontent_Spirotech_SpiroExpand_Intermediate Cooling EV_ET1500T1_INT-EN.ifc
Time: 2025-08-05T18:18:59+02:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.60.36 (ENG) - IFC 23.4.0.0

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Pset_SiteCommon - Reference: Project Information
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Project Information; sets with these values: 2
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuildingStorey: Level:Floor Level (3)
Pset_BuildingStoreyCommon - Reference: Floor Level
Other - Category: Levels; Family: Level; Family and Type: Level: Floor Level; Type: Floor Level; Type Id: 305
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent : standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Floor Level
Name | LongName = Name | Elevation (mm) = Constraints, Elevation (mm)
F00 | F00 | 0
F01 | F01 | 3300
F02 | F02 | 6600

# IfcBuildingElementProxy: HC_Expansion Vessel_MEPcontent_Spirotech_SpiroExpand_Intermediate Cooling EV_INT-EN:ET1500T1, HC_Expansion Vessel_MEPcontent_Spirotech_SpiroExpand_Intermediate Cooling EV_INT-EN:ET1500T1:1754386
In: F00
Type - Material: Color RGB 229-290-001, Color RGB 040-040-040, Color RGB 115-115-115, Color RGB 000-000-255, Color RGB 200-000-000
Type - Other - Category: Mechanical Equipment; 100: no; 1000: no; 150: no; 1500: yes; 200: no; 2000: no; 3000: no; 350: no; 500: no; 750: no; Connector 1 Elevation: 2536.21 mm; Connector 2 Elevation: 491 mm; Connector 2 Offset: 600 mm; Family Name: HC_Expansion Vessel_MEPcontent_Spirotech_SpiroExpand_Intermediate Cooling EV_INT-EN
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Connection Diameter: 80 mm; Diameter: 1000 mm; Height: 2536.21 mm; Use Nominal Diameter: yes
Type - Identity Data - Article Description: Intermediate cooling vessel 1500 ltr; Article Type: ET1500T1; Base Family Version: 25.09; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Custom: no; Description: Intermediate cooling vessel 1500 ltr; EMCS Version: 5.0; ETIM Article Class: EC010958; Family Version: 12.20; GLN: 8717811000007; GTIN: 8717811017364; Manufacturer: Spirotech; Manufacturer Art. No.: ET1500T1; Manufacturer URL: https://www.spirotech.com/8717811017364; MEPcontent Class: EXPANSIONVESSEL; Model: ET1500T1; OmniClass Number: 23.75.70.11.14; OmniClass Title: Expansion Vessels; Product Line: Spirotech; Revit Version: 2023; Type Name: ET1500T1; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Materials and Finishes - Black: Color RGB 040-040-040; Blue: Color RGB 000-000-255; Dark Grey: Color RGB 115-115-115; Red: Color RGB 200-000-000; Yellow: Color RGB 229-290-001
Type - Mechanical - Maximum Temperature (°C): 110; Pre-pressure: 0; Volume: 1.5 m3
Type - Pset_ManufacturerTypeInformation - Manufacturer: Spirotech
Pset_BuildingElementProxyCommon - Reference: ET1500T1; IsExternal: no
Pset_EnvironmentalImpactIndicators - Reference: ET1500T1
Other - Family: HC_Expansion Vessel_MEPcontent_Spirotech_SpiroExpand_Intermediate Cooling EV_INT-EN; Family and Type: HC_Expansion Vessel_MEPcontent_Spirotech_SpiroExpand_Intermediate Cooling EV_INT-EN: ET1500T1; Type: ET1500T1; Type Id: 1754353
Constraints - Elevation from Level: 0 mm; Offset from Host: 0 mm
Dimensions - Area: 28.3932 m2; Volume: 1.65339 m3
Identity Data - Mark: 4
Mechanical - System Classification: Undefined
Mechanical - Flow - Flow 1: 0 m3/s; Flow 2: 0 m3/s
Phasing - Phase Created: 3. New Construction

# IfcDistributionPort (2)
Description: Flow; FlowDirection: SOURCEANDSINK; PredefinedType: PIPE
Name
Port_1754386_1
Port_1754386_2
